SRC_URI = "https://ftp.acc.umu.se/pub/GNOME/sources/gtk/${MAJ_VER}/gtk-${PV}.tar.xz"

PACKAGECONFIG:remove = "vulkan"
