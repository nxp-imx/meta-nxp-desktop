# This is a runtime dependency which appears to be missing from
# the original recipe in the underlying SDK
RDEPENDS_${PN} += "attr"
