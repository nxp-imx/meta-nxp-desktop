# Apparently missing in the original recipe
RDEPENDS_${PN} += "liblzma"
RPROVIDES_${PN} += "liblzma"
