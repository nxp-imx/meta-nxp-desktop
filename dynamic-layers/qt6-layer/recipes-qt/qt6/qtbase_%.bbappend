PACKAGECONFIG_VULKAN_IMX_GPU:remove:mx8-nxp-bsp   = "vulkan"
