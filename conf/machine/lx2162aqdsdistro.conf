## conf/machine/lx2162aqdsdistro.conf
```bitbake
MACHINE="lx2162aqds"
require conf/machine/lx2162aqds.conf

require conf/machine/include/ubuntubasics.inc

HOSTTOOLS_NONFATAL:append = " bc"
```
