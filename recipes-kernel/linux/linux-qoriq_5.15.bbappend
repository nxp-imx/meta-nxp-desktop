FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-LF-6391-arm64-dts-ls1028a-rdb-fix-typo-for-DP-lane-m.patch \
    "

