require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b3b0bab6ff55420d043cf1652c52d788"

SRC_URI[md5sum] = "0cac177f6cb629561bc592835fadd8d0"
SRC_URI[sha256sum] = "dcd8b08dd9c49f1da630ce29ef81d6fd6cb17b06630eb02ca5bd789ca51b8ec6"

COMPATIBLE_MACHINE = "(mx8)"
