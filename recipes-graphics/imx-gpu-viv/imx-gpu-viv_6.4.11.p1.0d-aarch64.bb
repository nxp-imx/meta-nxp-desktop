require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "7b9fbbe0dee3a0d351ef3d8c9ada7128"
SRC_URI[sha256sum] = "870baaf1a6e0a1e5d8fd9ffbd2d037f6f1a169f5c27125a984815522a529db5c"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
