require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=03bcadc8dc0a788f66ca9e2b89f56c6f"

SRC_URI[md5sum] = "93a9de70699959dd91b60e7f14d90596"
SRC_URI[sha256sum] = "5a3284c54630bf52427c4d3bb7793ba5e35214a908b4b6ae6e3c0eee5bdecfc1"

COMPATIBLE_MACHINE = "(mx8)"
