require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=63a38e9f392d8813d6f1f4d0d6fbe657"

SRC_URI[md5sum] = "4c882d2beeed797b3f0b0f4b6fecd185"
SRC_URI[sha256sum] = "510c100df51837e3af13dbb4d251fa79b1572e09dd8357dc6bb9609e55338fec"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
