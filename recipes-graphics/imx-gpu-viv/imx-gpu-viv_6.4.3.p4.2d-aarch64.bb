require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d3c315c6eaa43e07d8c130dc3a04a011"

SRC_URI[md5sum] = "b2d78e7947c692e341d2ecec8bdfce1b"
SRC_URI[sha256sum] = "7826312e45aa857cf5ca6e42508c960351b4500d2ab5c3500fab2bb1f69d8950"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
