require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

SRC_URI[md5sum] = "31514d428d078e4a0525adb582780fcd"
SRC_URI[sha256sum] = "c0f74341eb0fbd24c0d85cbe5c7e070f59ebddb982cd575038eac4506e2651d0"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
