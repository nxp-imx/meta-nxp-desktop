require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

SRC_URI[md5sum] = "5b41e1f6af36ab5ee4f4249d29b038ab"
SRC_URI[sha256sum] = "45d20ea9f9b145308908112ed0f3422d32778dde06df9b48f3dbfcd97e793a33"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
