require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e565271ec9a80ce47abbddc4bffe56fa"

SRC_URI[md5sum] = "860d2a39d0c7581f49867ef89cbafcc3"
SRC_URI[sha256sum] = "96df9fd5f7bb8def14f6680fbb11df2efeafdfaeadded9fe35010faad753edb0"

COMPATIBLE_MACHINE = "(mx8)"
