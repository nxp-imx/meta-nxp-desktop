require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829"

SRC_URI[md5sum] = "12571b7a9c5c72b5cbf7e09c6bb1e131"
SRC_URI[sha256sum] = "5736ca455be88cabd6601cc3d664ab034f6f95a9df3b4e9bc84453be0396d3f4"

COMPATIBLE_MACHINE = "(mx8)"
