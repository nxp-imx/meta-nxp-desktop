require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "d190f0a21adbb7f7622c6c9a20d3d8b5"
SRC_URI[sha256sum] = "c0bf8f1849b80f5666817b83d6ef4022bf62416d468451f11591b3e79649743b"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
