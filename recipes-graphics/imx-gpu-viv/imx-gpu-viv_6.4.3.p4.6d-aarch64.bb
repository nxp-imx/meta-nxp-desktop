require imx-gpu-viv-6d.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "dad1c1208a254a84146c8aeb0fd0e7ab"
SRC_URI[sha256sum] = "47311f6468d814071b2c58ed7fd0874fa9c9327a2fc00c87fc66c64c8c80936e"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
