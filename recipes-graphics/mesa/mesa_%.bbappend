DEPENDS:remove = "vulkan-loader"
