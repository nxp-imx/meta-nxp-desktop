SRC_URI:remove = "file://tf-a-tests-no-warn-rwx-segments.patch \
"
