FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-wrappercamerabinsrc-don-t-send-drain-query-downstrea.patch \
"