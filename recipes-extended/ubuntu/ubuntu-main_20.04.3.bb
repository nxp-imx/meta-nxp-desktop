SUMMARY = "A prebuilt main image as baseline for custom work"
require ubuntu-base-image.inc
SECTION = "devel"

APTGET_EXTRA_PACKAGES_MAIN = "1"
