EXTRA_OEMAKE:append = " SBINDIR='${sbindir}' MANDIR='${mandir}'"
